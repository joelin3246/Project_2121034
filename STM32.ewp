# IAR project STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; source; source\include; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F0xx\Include; Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32.bin
  ILINK.IlinkOutputFile: STM32.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Library/EWARM
    Libraries/CMSIS/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Library/STM32F0xx_StdPeriph_Driver
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group Source
    source/: main.c RAM.c stm32f0xx_it.c system_stm32f0xx.c
  group Source/application
    source/: Display_sub.c Function.c I2c.c Incline.c Message.C Pulse.c ScanKey.c seven_tab.c SpeedDetection.c
  group Source/include
    source/include/: connect.H Display.h RAM.h stm32f0xx_conf.h
  group Source/Mode
    source/: EngineeringMode1_2.c EngineeringMode3_4.c HrcSportMode.c ManualSportMode.c ProgSetMode.c ProgSportMode.c SysCountDownMode.c SysErrMode.c SysPassMode.c SysSleepMode.c SysSportModeEnd.c SysStartMode.c UserSportMode.c
